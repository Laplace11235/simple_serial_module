## Kconfig
```kconfig
#

config SIMPLE_SERIAL_DEVICE
	tristate "simple serial kernel module"
	help
	It doesn't help you
```
